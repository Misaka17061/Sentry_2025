# Keil uVision project Sentry(2025).uvprojx, settings and files
target Sentry(2025) (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Sentry(2025) +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Appication/chassis;../Appication/gimbal;../BSP/inc;../Component/algorithms;../Component/Comm;../Component/drives;../Component/SoftwareTimer;../Component/utils;../Appication;..\Appication\platform;..\Component\drives\Super_Capacitor
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group BSP
    ../BSP/src/: bsp_can.c bsp_delay.c bsp_flash.c bsp_gpio.c bsp_i2c.c bsp_init.c bsp_uart.c
  group Component/algorithms
    ../Component/algorithms/: AHRS_middleware.c kalman.c kalman_filter.c pid.c ramp.c td.c user_lib.c AHRS.lib arm_cortexM4lf_math.lib ESO.c ADRC.c
  group Component/Comm
    ../Component/Comm/: client_ui_base.c comm_protocol.c crc.c referee_system.c computer_protocol.c user_protocol.c
  group Component/drives
    ../Component/drives/Buzzer/: buzzer.c
    ../Component/drives/IMU/: BMI088driver.c BMI088Middleware.c imu_driver.c ist8310driver.c ist8310driver_middleware.c
    ../Component/drives/Motor/: motor.c 9025motor.c
    ../Component/drives/RemoteControl/: remote_control.c et16s_rf209.c
    ../Component/drives/RGB_Led/: rgb_led.c
    ../Component/drives/Super_Capacitor/: super_capacitor.c
  group Component/SoftwareTimer
    ../Component/SoftwareTimer/: soft_timer.c
  group Component/utils
    ../Component/utils/: fifo.c
  group Application
    ../Appication/: app_init.c start_task.c timer_task.c imu_task.c sentry_console.c comm_task.c sentry_def.h detect_task.c ui_task.c
  group Application/gimbal
    ../Appication/gimbal/: gimbal_app.c gimbal_task.c gimbal_function.c shoot_task.c
  group Application/chassis
    ../Appication/chassis/: chassisl_app.c chassis_task.c chassis__function.c
  group Application/platform
    ../Appication/platform/: platform_app.c platform_task.c
software components: CMSIS:CORE 4.3.0
